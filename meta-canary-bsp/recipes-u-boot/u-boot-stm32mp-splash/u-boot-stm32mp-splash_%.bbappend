FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
UBOOT_SPLASH_LANDSCAPE_SRC = "canary_landscape.bmp" 
UBOOT_SPLASH_PORTRAIT_SRC = "canary_portrait.bmp"