FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://canary-bootstage.cfg;subdir=fragments/features"